Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 5bed9701-4ef5-4754-a544-c0c9e917ac44, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: INTEGRA MICRO-STAR F.ifc
Time: 2025-01-29T12:05:59+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: INTEGRA MICRO-STAR F:INTEGRA MICRO-STAR F, INTEGRA MICRO-STAR F:INTEGRA MICRO-STAR F:2518101
In: Default
Type - Material: Aluminium Druckguss - RAL9016, Kunststoff -PVC, Vorgabe_1
Type - Pset_ElementShading - Color: white
Material: Vorgabe_1
Pset_DistributionFlowElementCommon - Reference: INTEGRA MICRO-STAR F; sets with these values: 2
